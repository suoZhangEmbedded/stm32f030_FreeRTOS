# Keil uVision project project.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  AfterMake: fromelf.exe --bin -o ../output.bin ..\..\Project\MDK-ARM(uV4)\Flash\Obj/output.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F030
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\STM32F0x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS;..\..\User\FreeRTOS\Source\include;..\..\User\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\User\SEGGER_RTT\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group App
    ../../User/app/: main.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f0xx.c
  group MDK-ARM
    ../../Libraries/startup/: startup_stm32f030.s
  group StdPeriph_Driver
    ../../Libraries/STM32F0x_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dbgmcu.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group FreeRTOS
    ../../User/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../User/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../User/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group SEGGER_RTT
    ../../User/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
